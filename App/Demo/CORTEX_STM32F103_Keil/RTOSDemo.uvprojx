# Keil uVision project RTOSDemo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOSDemo +hex
  c flags: Optim=1
  c define: RVDS_ARMCM3_LM3S102
  c include: ..\Common\include;..\..\Source\include;.\STM32F10xFWLib\inc;..\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./: STM32F10x.s
    ../Common/drivers/ST/STM32F10xFWLib/src/: cortexm3_macro_rvds.s
    ./STM32F10xFWLib/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c
  group Demo Files
    ./ParTest/: ParTest.c
    ../Common/Minimal/: semtest.c BlockQ.c blocktim.c death.c flash.c integer.c PollQ.c
    ../Source/: main.c sim908.c
    ../Source/lcd_nokia5110/: nokia_5110.c
    ./: timertest.c
    ../Source/serial/: serial.c
  group FreeRTOS files
    ../../Source/: tasks.c list.c queue.c
    ../../Source/portable/RVDS/ARM_CM3/: port.c
    ../../Source/portable/MemMang/: heap_2.c
