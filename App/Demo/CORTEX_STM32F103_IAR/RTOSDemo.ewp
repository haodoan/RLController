# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: VECT_TAB_FLASH; IAR_ARM_CM3
  ICCARM.CCDiagSuppress: Pa082, pe191
  ICCARM.CCIncludePath2: ..\Source; STM32F10xFWLib\inc; ..\..\Source\include; ..\common\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .; ..\Source
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Demo files
    ../Common/Minimal/: BlockQ.c blocktim.c death.c flash.c integer.c PollQ.c semtest.c
    ../Source/: main.c sim908.c sim908.h
    ../Source/lcd_nokia5110/: nokia_5110.c
    ../Source/serial/: serial.c
    ./: stm32f10x_it.c
  group FreeRTOS files
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group ST Library
    STM32F10xFWLib/src/: cortexm3_macro.s lcd.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group System files
    ./: stm32f10x_vector.c
